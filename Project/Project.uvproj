# Keil uVision project Project.uvproj, settings and files
target LED (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\Startup;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\inc;..\Libraries\STM32F10x_StdPeriph_Driver_v3.5\src;..\User\Main;..\User\bsp\inc;..\User\bsp\src;..\User\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User/Main
    ../User/Main/: main.c stm32f10x_it.c modbus_slave.c modbus_slave.h
  group Libraries/StdPeriph_Driver_v3.5
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c
    ../Libraries/STM32F10x_StdPeriph_Driver_v3.5/inc/: stm32f10x_tim.h
  group Libraries/CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f10x_cl.s
  group Doc
    ../Doc/: information.txt
  group bsp
    ../User/bsp/src/: bsp_led.c bsp_relay.c bsp_uart_fifo.c bsp_timer.c bsp_user_lib.c bsp_limit_switch.c bsp_level_sensor_input.c
    ../User/bsp/inc/: bsp_led.h bsp_relay.h bsp_uart_fifo.h bsp_timer.h bsp_user_lib.h bsp_limit_switch.h bsp_level_sensor_input.h
    ../User/bsp/: bsp.c bsp.h
